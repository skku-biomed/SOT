<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\injectedADC_TIM6_5ms.ewp</path>
  </project>
  <batchBuild />
</workspace>
